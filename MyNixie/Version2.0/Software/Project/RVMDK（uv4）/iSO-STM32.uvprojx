# Keil uVision project iSO-STM32.uvprojx, settings and files
target Nixie Clock (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Firmware +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,DEBUG
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\User\SysTick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group BSP
    ../../User/: include.h bsp_led.c bsp_led.h bsp_SysTick.c bsp_SysTick.h bsp_usart1.c bsp_usart1.h ds3231.c ds3231.h bsp_i2c_gpio.c bsp_i2c_gpio.h bsp_beep.c bsp_beep.h bsp_ds18b20.c bsp_ds18b20.h WS2812B.c WS2812B.h other.c other.h remote.c remote.h sys.h bsp_74hc595.c bsp_74hc595.h eeprom.c eeprom.h SHT2x.c SHT2x.h iicSHT2x.c iicSHT2x.h
  group DOC
    ../../Doc/: readme.txt
